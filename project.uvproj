# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: DP80390XP Digital Core Design
  cpu: IRAM(0 - 0xFF) CLOCK(50000000) MOD_CONT MODDP2 MOD517AU
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\inc
  asm include: .\inc
  group src
    ./: START390.A51
    ./src/: heartbeat_task.c key_task.c main.c processor.c scheduler.c uart_task.c user.c watchdog_task.c
